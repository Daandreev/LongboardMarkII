File: Electronics/Battey Spacer 1/BatterySpacer1X9_Panel.brd (EAGLE design)
At the start: 93.5 x 93.5 mm, 0 parts

Commit message: connector PCBs and such
Other:
- outline, holes or cut-outs redrawn
